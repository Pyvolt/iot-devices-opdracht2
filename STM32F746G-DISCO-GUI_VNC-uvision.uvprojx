# Keil uVision project STM32F746G-DISCO-GUI_VNC-uvision.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x0003C000) IROM(0x08000000,0x00100000) IROM2(0x00200000,0x00100000) XRAM(0x2004C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746G-DISCO-GUI_VNC-uvision
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x2004c000 size 0x4000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x3c000
  group Source Group 1
    ./: Blinky.c retarget_stdio.c vio.c GUI_SingleThread.c FramewinDLG.c LCD_X.c Touch_746G_Discovery.c stm32746g_discovery_ts.c ft5336.c stm32746g_discovery.c HTTP_Server_CGI.c
    Web/: Web.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c system_stm32f7xx.c stm32f7xx_hal_timebase_tim.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f746xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_mmc.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c
  group Web files
    ./Web/: ad.cgi ad.cgx arm.png buttons.cgi buttons.cgx home.png index.htm keil.gif language.cgi lcd.cgi leds.cgi llblue.jpg network.cgi pabb.gif pg_footer.inc pg_header.inc system.cgi tcp.cgi xml_http.js index2.cgi
software components: CMSIS Driver:VIO:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.1, CMSIS Driver:Ethernet MAC 3.2.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:GPIO 1.2.0, CMSIS Driver:USART 3.0.0, Device:CubeMX 1.0.0, Network:CORE 8.2.0, Network:Interface:ETH 8.2.0, Network:Service:Web Server Compact 8.2.0, Network:Socket:BSD 8.2.0, Network:Socket:TCP 8.2.0, Network:Socket:UDP 8.2.0, Graphics:CORE 6.32.3, Graphics:Display:Interface Template 6.32.3, Graphics:Input Device:Touchscreen 6.32.3, Graphics:Tools:GUI Builder 6.32.3, Graphics:VNC Server 6.32.3
